# Keil uVision project NPC120KWPCS_ARM.uvprojx, settings and files
target 6KW (5060020::V5.06 (build 20)::.\ACOMP5)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NPC120KWPCS_ARM +hex
  AfterMake: D:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\..\Libraries\GD32F30x_standard_peripheral\Include;..\..\Libraries\CMSIS\GD\GD32F30x\Include;..\..\Libraries\CMSIS;.\user;.\BSP;.\BSP\inc;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\Middlewares\FreeRTOS\include;..\..\Comm\lcd\inc;..\..\Comm\modbus;..\..\Comm\segger\HardFaultHandlerMDK;.\app;.\app\inc;..\..\Comm\store;..\..\Comm\lcd;..\..\Comm\store\24cxx;.\BSP\CAN;..\..\Comm;..\..\Comm\modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x3cfff
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../../Libraries/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Startup
    ../../Libraries/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group User
    ./user/: main.c gd32f30x_it.c includes.h gd32f30x_libopt.h FreeRTOSConfig.h
  group App
    ./app/: app.c app_timer.c
    ./app/src/: app_can.c app_slaveIap.c
    ../../Comm/: sysfuc.c
  group BSP
    ./BSP/: bsp.c
    ./BSP/src/: bsp_led.c bsp_timer.c bsp_i2c_gpio.c bsp_eeprom_24xx.c bsp_mcu_flash.c bsp_uart_it.c bsp_uart_dma.c bsp_uart_com.c bsp_user_lib.c bsp_dri_can.c bsp_watchdog.c SysInfoTest.c bsp_tim_pwm.c bsp_adc.c bsp_Relay.c bsp_digital_tube.c
    ./BSP/CAN/: CAN.c
  group FreeRTOS/Ports
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/Source
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group GD32F30x_Firmware_Library
    ../../Libraries/GD32F30x_standard_peripheral/Source/: gd32f30x_gpio.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_rcu.c gd32f30x_pmu.c gd32f30x_misc.c gd32f30x_fmc.c gd32f30x_dma.c gd32f30x_can.c gd32f30x_dbg.c gd32f30x_fwdgt.c gd32f30x_adc.c
  group SEGGER/HardFault
    ../../Comm/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group component/modbus
    ../../Comm/modbus/: dat_para.c modbus_host.c modbus_slave.c myqueue.c
